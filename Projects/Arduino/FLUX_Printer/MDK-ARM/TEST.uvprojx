# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Keil_μVision4;..\..;..\..\TEST;..\..\..\Common;..\..\..\..\Libraries\Arduino\inc;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\Libraries\CMSIS\Include;C:\Keil_v5\ARM\Pack\test\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;C:\Keil_v5\ARM\Pack\test\Libraries\CMSIS\Include;C:\Keil_v5\ARM\Pack\test\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_CPAL_Driver\inc;C:\Keil_v5\ARM\Pack\test\Libraries\STM32F0xx_StdPeriph_Driver\inc;C:\Keil_v5\ARM\Pack\test\Utilities\STM32_EVAL\STM320518_EVAL;C:\Keil_v5\ARM\Pack\test\Utilities\STM32_EVAL\Common;..\..\..\..\Libraries\CMSIS\Include;..\..\FLUX_Printer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group STM32_Library
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_rtc.c stm32f0xx_wwdg.c stm32f0xx_iwdg.c stm32f0xx_dma.c
    ../: stm32f0xx_flash.c
  group Arduino
    ../../../../Libraries/Arduino/src/: serial.c gpio.c
  group Src
    ../: stm32f0xx_it.c setup.c loop.c stm32f0xx_i2c.c lis302dl.c command.c configuration.c uart.c heater.c Six_Axis_Sensor.c
    ../../../Common/: utilities.c system_stm32f0xx.c
    ../../: main.c
  group Module
    ../: LaserModule.c Extruder_One_Module.c Extruder_Duo_Module.c
